## boards/st/nucleo/Kconfig.nucleo
```kconfig
# Copyright (c) 2023 Thomas Stranger
# SPDX-License-Identifier: Apache-2.0

config BOARD_NUCLEO
	select SOC_STM32H533XX
```
